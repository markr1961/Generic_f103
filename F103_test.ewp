# IAR project F103_test.ewp, settings and files
configuration F103-release (ARM)
  General.OGChipSelectEditMenu: STM32F103C6 ST STM32F103C6
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: STM32F10X_HD_VL; USE_STDPERIPH_DRIVER; __ICCARM__
  ICCARM.CCDiagSuppress: Pa039
  ICCARM.CCIncludePath2: Inc; ..\STM32F10x_StdPeriph_Lib\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x; ..\STM32F10x_StdPeriph_Lib\Libraries\STM32F10x_StdPeriph_Driver\inc
  ICCARM.CCOptLevel: 2
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: $TARGET_BPATH$.bin
  ILINK.IlinkOutputFile: F103Test.out
  ILINK.IlinkIcfFile: F103_test.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration F103-debug (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: STM32F10X_LD; USE_STDPERIPH_DRIVER; DEBUG; __ICCARM__
  ICCARM.CCOptLevel: 1
  ILINK.IlinkIcfFile: C:\Users\221027001\OneDrive - gecurrent\git-projects-ARM\generic_F103\F103_test.icf
  group (top)
    ./: F103_test.c
  group Driver
    Drv/: Clocks.c GPIO_Init.c Hardware.c NVIC.c stm32f10x_it.c WDog.c
  group Include
    Inc/: Clocks.h GPIO_Init.h Hardware.h ICF_Symbols.h NVIC.h Pin_Defs.c Pin_Defs.h WDog.h
  group start-up
    ../STM32F10x_StdPeriph_Lib/Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/iar/: startup_stm32f10x_md.s
  group STM32F10x_StdPeriph_Lib
    ../STM32F10x_StdPeriph_Lib/Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
